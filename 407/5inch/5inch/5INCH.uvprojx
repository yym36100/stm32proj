# Keil uVision project 5INCH.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 5INCH
  group src
    ./Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
    ./: startup_stm32f407xx.s STM32F407VETx_FLASH.ld STM32F407VETX_RAM.ld
  group drivers
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sram.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c
